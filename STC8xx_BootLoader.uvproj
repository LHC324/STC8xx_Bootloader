# Keil uVision project STC8xx_BootLoader.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8xx_BootLoader +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Inc
  group Src
    ./Src/: usart.c eeprom.c GPIO.c main.c spi.c w25qx.c
